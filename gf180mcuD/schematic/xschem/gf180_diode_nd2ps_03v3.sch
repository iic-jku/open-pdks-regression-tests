v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 400 -280 400 -300 {lab=A}
N 400 -220 400 -200 {lab=C}
C {devices/title.sym} 160 -30 0 0 {name=l5 author="Julian Schwarz 2026"}
C {gf180mcu_fd_pr/diode_nd2ps_03v3.sym} 400 -250 0 0 {name=D1
model=diode_nd2ps_03v3
r_w=0.36u
r_l=0.36u
m=1
}
C {iopin.sym} 400 -300 3 0 {name=p1 lab=A}
C {iopin.sym} 400 -200 1 0 {name=p2 lab=C}
