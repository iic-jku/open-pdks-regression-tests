** sch_path: ihp-sg13cmos5l/schematic/xschem/sg13_ind_lvsres.sch
**.subckt sg13_ind_lvsres LA LB
*.iopin LA
*.iopin LB
RR1 LA net1 1e-6
RR2 net1 LB 1e-6
**.ends
.end
