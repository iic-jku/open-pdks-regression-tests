** sch_path: ihp-sg13cmos5l/schematic/xschem/sg13_combined.sch
**.subckt sg13_combined VDD VSS G
*.iopin VDD
*.iopin VSS
*.iopin G
XM1 net1 G VSS VSS sg13_lv_nmos w=1.0u l=0.72u ng=1 m=1 rfmode=1 mm_ok=1
XM2 net1 G VDD VDD sg13_lv_pmos w=1.0u l=0.72u ng=1 m=1 rfmode=1 mm_ok=1
XD1 [expr {$lvs_ignore ? {VSS} : {psub}}] net2 dantenna l=0.78u w=0.78u
XD2 net2 net3 dpantenna l=0.78u w=0.78u
XM3 net2 VSS VSS [expr {$lvs_ignore ? {VSS} : {psub}}] sg13_lv_nmos w=0.15u l=0.45u ng=1 m=1 mm_ok=1
XM4 net2 VDD VDD net3 sg13_lv_pmos w=0.15u l=0.45u ng=1 m=1 mm_ok=1
XM5 net2 VDD VDD net3 sg13_hv_pmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM6 net2 VSS VSS [expr {$lvs_ignore ? {VSS} : {psub}}] sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM7 net4 G VSS VSS sg13_hv_nmos w=1.0u l=0.72u ng=1 m=1 rfmode=1 mm_ok=1
XM8 net4 G VDD VDD sg13_hv_pmos w=1.0u l=0.72u ng=1 m=1 rfmode=1 mm_ok=1
XR1 net6 net4 [expr {$lvs_ignore ? {VSS} : {psub}}] rsil w=0.5e-6 l=0.5e-6 m=1 mm_ok=1
XR2 net5 net6 [expr {$lvs_ignore ? {VSS} : {psub}}] rppd w=0.5e-6 l=0.5e-6 m=1 b=0 mm_ok=1
XR3 net1 net5 [expr {$lvs_ignore ? {VSS} : {psub}}] rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
XR4 VSS [expr {$lvs_ignore ? {VSS} : {psub}}] ptap1 R=17.81 w=3e-6 l=4e-6 rw=0.3e-6
XR5 VDD net3 ntap1 R=14.42 w=4.5e-6 l=4e-6 rw=0.3e-6
**.ends
.end
